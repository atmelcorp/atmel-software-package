# IAR project getting_started.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAMA5D27 Atmel SAMA5D27
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD_SAMA5D2_XPLAINED; API_PIOv4; SERIE_SAMA5D2; CHIP_SAMA5D27; sram
  ICCARM.CCIncludePath2: ../../; ../../drivers; ../../examples; ../../lib; ../../target; ../../target/include; ../../target/sama5d2
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ../../drivers; ../../examples; ../../lib; ../../target; ../../utils; ../../target/include; ../../target/sama5d2
  OBJCOPY.OOCOutputFile: getting_started.bin
  ILINK.IlinkOutputFile: getting_started.out
  ILINK.IlinkIcfFile: ..\..\target\resources\iar\sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
  group drivers/bus
    ../../drivers/bus/: can.c console.c spi.c ssc.c twi.c twid.c xdmad.c
  group drivers/core
    ../../drivers/core/: aic.c async.c cp15.c cp15_asm_iar.s cp15_pmu.c l2cc.c mmu.c pio4.c pio4_it.c pmc.c pwmc.c rstc.c wdt.c
  group drivers/io
    ../../drivers/io/: act8945A.c led.c mcid.h
  group drivers/serial
    ../../drivers/serial/: flexcom.c uart.c usart.c
  group drivers/time
    ../../drivers/time/: pit.c rtc.c rtc_calib.c tc.c timetick.c
  group ressources
    ../../target/resources/iar/: sram.icf
  group startup
    ../../target/sama5d2/: board_cstartup_iar.s board_lowlevel.c board_memories.c
