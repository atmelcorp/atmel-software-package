# IAR project test_board_hw.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD_SAMA5D2_XPLAINED; API_PIOv4; SERIE_SAMA5D2; CHIP_SAMA5D21
  ICCARM.CCIncludePath2: ../../; ../../drivers; ../../examples; ../../lib; ../../target; ../../target/include; ../../target/sama5d2
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ../../drivers; ../../examples; ../../lib; ../../target; ../../utils; ../../target/include; ../../target/sama5d2
  OBJCOPY.OOCOutputFile: test_board_hw.srec
  ILINK.IlinkOutputFile: test_board_hw.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  group (top)
    ../../drivers/core/: aic.c pio4.c pio4_it.c pmc.c pmc_d2.c
    ../../drivers/bus/: console.c twi.c twi.h
    ./: main.c
    ../../drivers/time/: rtc.c
    ../../drivers/serial/: uart.c usart.c
