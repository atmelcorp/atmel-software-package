# IAR project qspi_flash_loader.ewp, settings and files
configuration sama5d2-xplained_sram (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMA5D27 Atmel SAMA5D27
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SOFTPACK_VERSION="1.2 (v1.2-93-g70c446a-dirty)"; TRACE_LEVEL=5; CONFIG_TIMER_POLLING; CONFIG_SOC_SAMA5; CONFIG_SOC_SAMA5D2; CONFIG_SOC_SAMA5D27; CONFIG_BOARD_SAMA5D2_XPLAINED; CONFIG_HAVE_FLEXCOM; CONFIG_HAVE_PIO4; CONFIG_HAVE_QSPI; CONFIG_HAVE_MCAN; CONFIG_HAVE_SDMMC; CONFIG_HAVE_PMIC_ACT8945A; CONFIG_HAVE_USART_FIFO; CONFIG_HAVE_USART_LIN; CONFIG_HAVE_SPI_FIFO; CONFIG_HAVE_TWI_FIFO; CONFIG_HAVE_GMAC_QUEUES; CONFIG_HAVE_DDR3; CONFIG_HAVE_DDR3_SELFREFRESH; CONFIG_HAVE_TWI_ALTERNATE_CMD; CONFIG_HAVE_ADC_SETTLING_TIME; CONFIG_HAVE_ADC_INPUT_OFFSET; CONFIG_HAVE_ADC_INPUT_GAIN; CONFIG_HAVE_ADC_SEQ_R2; CONFIG_HAVE_PMC_FAST_STARTUP; CONFIG_HAVE_PMC_GENERATED_CLOCKS; CONFIG_HAVE_PMC_AUDIO_CLOCK; CONFIG_HAVE_PWM_EXTERNAL_TRIGGER; CONFIG_HAVE_L2CC; CONFIG_HAVE_XDMAC
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\utils; ..\..\..\..\..\..\target\sama5d2; ..\..\..\..\..\..\drivers; ..\..\..\..\..\..\lib; $PROJ_DIR$
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\..\..\..\utils; ..\..\..\..\..\..\target\sama5d2; ..\..\..\..\..\..\drivers; ..\..\..\..\..\..\lib
  OBJCOPY.OOCOutputFile: qspi_flash_loader.bin
  postbuild: cmd /c "copy /Y "sama5d2-xplained_sram\Exe\qspi_flash_loader.out" "..\sama5d2-xplained_qspi.out""
  ILINK.IlinkOutputFile: qspi_flash_loader.out
  ILINK.IlinkIcfFile: qspi_flash_loader.icf
  ILINK.IlinkProgramEntryLabel: FlashInitEntry
  group (top)
    ./: interface.c pin_defs_sama5d2.c qspi_flash_loader.c
  group drivers
    ../../../../../../drivers/peripherals/: acc.c aic.c flexcom.c l2cc.c matrix.c pio4.c pit.c pmc.c qspi.c sfc.c spi.c spid.c tc.c twi.c twid.c uart.c usart.c usartd.c
    ../../../../../../drivers/power/: act8945a.c
    ../../../../../../drivers/misc/: console.c cache.c
    ../../../../../../drivers/cortex-a/: cortexa5_interrupts.c cp15.c cp15_asm_iar.s cp15_pmu.c cpsr_iar.s mmu.c
    ../../../../../../drivers/memories/: qspiflash.c spi-nor.c
  group framework2
    framework2/: flash_loader.c flash_loader_asm.s
  group target
    ../../../../: board_support.c chip.c
  group utils
    ../../../../../../utils/: dbg_util.c mutex.c mutex_iar.s syscalls.c timer.c trace.c
