<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$/qspi_flash_loader.ewp</path>
  </project>
</workspace>
